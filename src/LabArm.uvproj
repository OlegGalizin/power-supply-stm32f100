# Keil uVision project LabArm.uvproj, settings and files
target LabArm (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LabArm +hex
  c flags: Optim=4
  c define: STM32F10X_LD_VL BIG REAL_FLASH AWD_ENABLED CLOCK_ENABLED GRAPH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group asm
    ./: STM32F10x.s
  group Src
    ./: n3310.c event.c LabArm.c config.c ui.c calibration.c clock.c graph.c
