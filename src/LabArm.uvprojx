# Keil uVision project LabArm.uvprojx, settings and files
target LabArm (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LabArm +hex
  c flags: Optim=4
  c define: STM32F10X_LD_VL BIG REAL_FLASH AWD_ENABLED CLOCK_ENABLED GRAPH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group asm
    ./: STM32F10x.s
  group Src
    ./: n3310.c event.c LabArm.c config.c ui.c calibration.c clock.c graph.c
software components: CMSIS:CORE 3.40.0
